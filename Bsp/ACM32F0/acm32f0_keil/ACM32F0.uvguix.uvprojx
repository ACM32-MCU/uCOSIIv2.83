# Keil uVision project ACM32F0.uvguix.uvprojx, settings and files
target ACM32F0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ACM32F0 +hex
  AfterMake: fromelf.exe --bin --output ./Out_Files/ACM32F0.bin ./Objects/ACM32F0.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .;..\Core_Drivers\CMSIS;..\Core_Drivers\Device;..\Core_Drivers\HAL_Driver\Inc;..\..\..\Micrium\Software\uCOS-II\Source;..\..\..\Ports\ARM-Cortex-M0\ARM
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CoreDriver/CMSIS
    ../Core_Drivers/CMSIS/: core_cm0.h
  group CoreDriver/Device
    ../Core_Drivers/Device/: ACM32F0x0.h Startup_ACM32F0x0.s System_ACM32F0x0.c System_ACM32F0x0.h
  group CoreDriver/HAL
    ../Core_Drivers/HAL_Driver/Inc/: ACM32Fxx_HAL.h
    ../Core_Drivers/HAL_Driver/Src/: HAL_DMA.c HAL_GPIO.c HAL_UART.c HAL_EFlash.c HAL_EFlash_EX.lib
  group Demo_Source
    ./: main.c bsp.c
  group RTOS_Source
    ../../../Micrium/Software/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group Ports
    ../../../Ports/ARM-Cortex-M0/: os_cpu_c.c
    ../../../Ports/ARM-Cortex-M0/ARM/: os_cpu_a.asm os_dbg.c
